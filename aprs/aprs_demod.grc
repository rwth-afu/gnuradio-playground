options:
  parameters:
    author: tim
    generate_options: qt_gui
    id: aprs_demod
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: samp_rate_paused
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 3,0,1,1
    label: pause
    pressed: samp_rate
    released: '0'
    type: int
    value: samp_rate
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate)
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1700+1000
    low_cutoff_freq: 1700-1000
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/out/afsk_signal_demod_out.f32
    type: float
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/out/afsk_signal_demod_out_lp.f32
    type: float
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/out/afsk_signal_demod_out_hp.f32
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/in/gnuradio_aprs_cut.c64
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_paused
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: ''
  states: {state: disabled}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 1200+500
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1200+500
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1200*1.5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color2: '"magenta"'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 2,0,1,1
    label1: Raw input
    label2: Low pass
    label3: High pass
    name: '"Aduio signals"'
    nconnections: '3'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    name: '"Audio from narrow FM demodulation"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: Low pass
    label2: High pass
    label3: difference
    name: High and Low pass signals
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: '"Input"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Audio from narrow FM demodulation"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_throttle_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [band_pass_filter_0, '0', high_pass_filter_0, '0']
- [band_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [blocks_abs_xx_0, '0', blocks_file_sink_0_0, '0']
- [blocks_abs_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_abs_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_file_source_0, '0', analog_nbfm_rx_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [high_pass_filter_0, '0', blocks_abs_xx_0_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '2']
- [low_pass_filter_0_0, '0', blocks_abs_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_time_sink_x_0_0, '2']

metadata:
  file_format: 1
