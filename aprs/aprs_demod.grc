options:
  parameters:
    author: tim
    generate_options: qt_gui
    id: aprs_demod
    output_language: python
    title: APRS demodulation
  states: {}

blocks:
- name: baud_rate
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: int(samp_rate)
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1700+1000
    low_cutoff_freq: 1700-1000
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_abs_xx_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_abs_xx_0_0
  id: blocks_abs_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/out/afsk_signal_demod_out.f32
    type: float
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/out/decoded_bits.i8
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/tim/git/rwth-afu-gnuradio-playground/aprs/in/gnuradio_aprs_cut.c64
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """ outputs 1 if the input is above the threshold, else 0 """

          def __init__(self, threshold=0.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Compare',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              
              # keep the input as a value
              self.threshold = threshold

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] > self.threshold
              return len(output_items[0])
    threshold: '0.0'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """ Extracts the bitstream from an NRZI binary stream (In a not very efficient way) """

          def __init__(self, sample_rate=50e3, data_rate=1200):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              # save parameter
              self.symbol_duration = sample_rate / data_rate
              print('symbol_duration', self.symbol_duration)
              
              # initialize parent
              gr.basic_block.__init__(
                  self,
                  name='NRZI decoder',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.int8],
              )
              
              # create class variabels
              self.leftover_last_work = 0.0
              self.last_value = 0
              self.first_work = True
              
              self.dump = open('/tmp/raw_dump.txt', 'w')
              
          '''
          def join_glitches(self, arr):
              """ a generator that removes glitches that are less than the symbol duration from the interval list """
              idx = 0
              while idx < len(arr):
                  cnt = 1
                  while idx+cnt < len(arr)-2 and sum(arr[idx:idx+cnt+2]) < self.symbol_duration*0.8:
                      cnt += 2
                  
                  yield sum(arr[idx:idx+cnt])
                  idx += cnt
          '''

          def general_work(self, input_items, output_items):
              """ measure the distance between the edges and calculate an estimate for the bistream based on that """
              # use all available input data
              self.consume(0, len(input_items[0]))
              
              # print('in/out len', len(input_items[0]), len(output_items[0]))
              samples = input_items[0]
              
              # find the edges
              changes = np.array(np.nonzero(samples[1:] - samples[:-1])[0])

              # print(len(samples), (len(samples)-1-changes[-1]) if len(changes)>0 else None, samples[0], self.last_value, self.leftover_last_work, changes[0])
                      
              # estimate the bit-stream
              change_interval = list(changes[1:] - changes[:-1])
              
              # handle leftover data from last time
              if not self.first_work:
                  if len(changes) > 0:
                      if samples[0] != self.last_value:
                          change_interval = [self.leftover_last_work, changes[0]] + change_interval
                      else: # there was no edge between the last and current block
                          # change_interval[0] += self.leftover_last_work
                          change_interval = [self.leftover_last_work + changes[0]] + change_interval
                  else:
                      self.leftover_last_work += len(samples)
                      return 0
              else:
                  self.first_work = False

              # change_interval = self.join_glitches(change_interval) # optional de-glitching
              
              bits = [[1]*int(np.round(interval/self.symbol_duration)-1) + [0] for interval in change_interval]
              bits = sum(bits, [])
              
              # dump bits for debugging
              for i in bits:
                   self.dump.write(f"{i}\n")
              #self.dump.write(f"l {self.last_value} {self.leftover_last_work}\n")
              #self.dump.write(f"c {repr(changes)}\n")
              #self.dump.write(f"i {repr(change_interval)}\n")
              #self.dump.write(f"b {repr(bits)}\n\n")
              
              # save ending details for next iteration
              self.last_value = samples[-1]
              if len(bits) > 0:
                  self.leftover_last_work = len(samples)-1 - changes[-1]
              else:
                  self.leftover_last_work += len(samples)
              # print(len(bits))
              
              # return results
              output_items[0][:len(bits)] = bits
              return len(bits)
    data_rate: '1200'
    sample_rate: '50000'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, ):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='sync to APRS frames',   # will show up in GRC
                  in_sig=[np.int8],
                  out_sig=None
              )
              
              self.message_port_register_out(gr.pmt.intern('aprs_msg'))

              
              self.started_data = []
              # self.is_synced = False
              self.leftover_bits = []

          def bitstream_to_bytes_big_endian(self, bitstream):
              """ convert a bitstream to bytes """
              assert len(bitstream)%8 == 0
              data = np.reshape(bitstream, (len(bitstream)//8, 8)) 
              data = np.sum(data * np.array([2**(i) for i in range(8)]), axis=1)
              return data

          def parse_packet(self, data):
              """ parse the APRS packet components """
              data = np.array(data)
              
              # determine the digipeater path field lenght (I'm absolutely not sure that this is the intended way!)
              control_field_idx = None
              for idx in range(14,len(data)-1):
                  if (data[idx:idx+2] == [0x03, 0xf0]).all():
                      control_field_idx = idx 
                      break
              if control_field_idx is None:
                  return None

              # parse package
              package = {}
              package['dst_addr'] = bytes(list(data[:7]>>1))
              package['src_addr'] = bytes(list(data[7:14]>>1))
              package['digipeater_addr'] = bytes(list(data[14:control_field_idx]>>1))
              package['data'] = bytes(list(data[control_field_idx+2:-1]))
              package['fcs'] = data[-1]

              return package 


          def general_work(self, input_items, output_items):
              """
                  search for sync sqeuence and read until next sync is found (skipping all empty syncs)
                  Also handles the stuffed ones (A zero is inserted after 5 continuous ones unless inside the sync pattern)
              """
              # tell gnuradio we took the sequence
              self.consume(0, len(input_items[0]))
              
              # add last 7 bits to the front of our bitstream in case we did not end with a sync from last frame
              bitstream = self.leftover_bits + list(input_items[0])
              
              # extract the frames based on the sync pattern
              idx = 0
              acc = []
              frames = []
              stuffing_count_ones = 0
              
              while idx < len(bitstream)-8:
                  # check for sync
                  if bitstream[idx:idx+8] == [0, 1, 1, 1, 1, 1, 1, 0]:
                      if len(acc) > 0:
                          frames.append(acc)
                          acc = []
                          stuffing_count_ones = 0
                      idx += 8
                  # no sync -> record frame and handle bit stuffing
                  else:
                      if bitstream[idx]:
                          stuffing_count_ones += 1
                          acc.append(bitstream[idx])
                      else:
                          if stuffing_count_ones < 5: # handle bit stuffing
                              acc.append(bitstream[idx])
                          else:
                              # print('skipping stuffed one')
                              pass
                          stuffing_count_ones = 0
                      idx += 1
              
              if len(frames) > 0:
                  frames[0] = self.started_data + frames[0]
                  self.started_data = []
              
              for f in frames:
                  # send a message if we have a valid frame
                  if len(f)%8 == 0:
                          bytes = self.bitstream_to_bytes_big_endian(f)
                          aprs_msg = self.parse_packet(bytes)
                          self.message_port_pub(gr.pmt.intern('aprs_msg'), gr.pmt.intern(repr(aprs_msg)))
                          # print('found frame', str(aprs_msg))
              
              # store leftover bits
              self.leftover_bits = bitstream[idx:]
              self.started_data += acc

              return 0
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 1200+500
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1200+500
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1200*1.5
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    key: aprs_msg
    type: string
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color2: '"magenta"'
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 2,0,1,1
    label1: Raw input
    label2: Low pass
    label3: High pass
    name: '"Aduio signals"'
    nconnections: '3'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1,1,1
    name: '"Audio from narrow FM demodulation"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1,1,1
    label1: Low pass
    label2: High pass
    label3: difference
    label4: Differnce over threshold
    name: High and Low pass signals
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 3,1,1,1
    label1: Decoded bitstream
    size: '128'
    srate: baud_rate
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 0,0,1,2
    name: '"Input"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    gui_hint: 1,0,1,1
    name: '"Audio from narrow FM demodulation"'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_nbfm_rx_0, '0', blocks_throttle_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [band_pass_filter_0, '0', high_pass_filter_0, '0']
- [band_pass_filter_0, '0', low_pass_filter_0_0, '0']
- [blocks_abs_xx_0, '0', blocks_sub_xx_0, '0']
- [blocks_abs_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_abs_xx_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_abs_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', analog_nbfm_rx_0, '0']
- [blocks_file_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_sub_xx_0, '0', low_pass_filter_0_0_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0, '3']
- [epy_block_1, '0', blocks_char_to_float_0, '0']
- [epy_block_1, '0', blocks_file_sink_1, '0']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_2, aprs_msg, blocks_message_debug_0, print]
- [epy_block_2, aprs_msg, qtgui_edit_box_msg_0, val]
- [high_pass_filter_0, '0', blocks_abs_xx_0_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '2']
- [low_pass_filter_0_0, '0', blocks_abs_xx_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_0, '1']
- [low_pass_filter_0_0_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0_0_0, '0', epy_block_0, '0']
- [low_pass_filter_0_0_0, '0', qtgui_time_sink_x_0_0, '2']

metadata:
  file_format: 1
