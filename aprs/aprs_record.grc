options:
  parameters:
    author: tim
    generate_options: qt_gui
    id: APRS_recording
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 144.7e6
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: 0.1e6
  states: {}
- name: range_bb_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,1,1,1
    label: Baseband Gain
    orient: Qt.Horizontal
    start: '0'
    step: '2'
    stop: '62'
    value: '16'
  states: {}
- name: range_if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: IF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '8'
    stop: '40'
    value: '32'
  states: {}
- name: range_rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '14'
    stop: '14'
    value: '0'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/gnuradio_aprs.c64
    type: complex
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_offset
    decim: decimation
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1, samp_rate, samp_rate/(2*decimation), samp_rate/(2*decimation)/10 )'
    type: ccc
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: hackrf
    bb_gain0: range_bb_gain
    freq0: center_freq
    gain0: range_rf_gain
    gain_mode0: 'False'
    if_gain0: range_if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: center_freq
    fftsize: '4096'
    gui_hint: 0,0,1,2
    name: '"Input signal"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 2,0,3,1
    label1: I Signal
    label2: Q signal
    name: '"Input signal"'
    size: 1024*8
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,0,1,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate/decimation
    fc: center_freq+freq_offset
    fftsize: '1024'
    gui_hint: 5,0,1,2
    name: '"Selected bandwidth"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', blocks_file_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [osmosdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
